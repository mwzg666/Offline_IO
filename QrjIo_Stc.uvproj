# Keil uVision project QrjIo_Stc.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: QrjIo_Stc +hex
  link misc: REMOVEUNUSED
  group adc12
    ./adc12/: adc12.c
  group Ads1110
    ./Ads1110/: ads1110.c
  group iic
    ./iic/: i2c.c
  group Io
    ./IO/: io.c
  group mcp4725
    ./mcp4725/: mcp4725.c
  group MwPro
    ./MwPro/: MwPro.c
  group uart
    ./uart/: Uart.c
  group User
    ./User/: main.c system.c
